Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Jun-Dining Table 320x120 - ver4.ifc
Time: 2024-11-07T11:32:12
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Jun-Dining Table 320x120_0 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_1 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_2 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_3 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_4 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_5 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_6 - ObjectType: SketchupGroup
 | Jun-Dining Table 320x120_7 - ObjectType: SketchupGroup
